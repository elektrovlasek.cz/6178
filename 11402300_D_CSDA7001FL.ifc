Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-02-06T08:06:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 06 08:06:56 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{74B50B4F-09AF-4D18-97A1-52995427FA9E}\ifc * Database version: 5507 * Database creation date: Thu Feb 06 08:06:54 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 06 08:06:54 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 06 08:06:54 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 27700150_D_11402300_CSDA7001FL, 11402300_D_CSDA7001FL:27700150_D_11402300_CSDA7001FL:205202
In: Level 1
Type - Material: z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_CLST, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - Reference: 27700150_D_11402300_CSDA7001FL
